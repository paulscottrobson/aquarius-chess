; ***************************************************************************************
; ***************************************************************************************
;
;		Name : 		stack.asm
;		Author :	Paul Robson (paul@robsons.org.uk)
;		Date : 		5th January 2019
;		Purpose :	Stack words
;
; ***************************************************************************************
; ***************************************************************************************

@macro 	push
	push 	hl
@end

@macro	pop
	ex 		de,hl
	pop 	hl
@end

; ***************************************************************************************

@macro 	a>r
	push 	hl
@end

@macro 	r>a
	pop 	hl
@end

; ***************************************************************************************

@macro 	b>r
	push 	de
@end

@macro 	r>b
	pop 	de
@end

; ***************************************************************************************

@macro 	c>r
	push 	bc
@end

@macro 	r>c
	pop 	bc
@end


; ***************************************************************************************

@macro 	ab>r
	push 	de
	push 	hl
@end

@macro 	r>ab
	pop 	hl
	pop 	de
@end

; ***************************************************************************************

@macro 	abc>r
	push 	bc
	push 	de
	push 	hl
@end

@macro 	r>abc
	pop 	hl
	pop 	de
	pop 	bc
@end
